export prefix = "/usr/lib/${PN}"
export exec_prefix = "/usr/bin/${PN}"

FILES:${PN} += " /usr/lib/ /usr/bin/ "
