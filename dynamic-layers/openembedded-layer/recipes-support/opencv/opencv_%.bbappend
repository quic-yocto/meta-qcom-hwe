PACKAGECONFIG:append:qcom = "tests"
PACKAGECONFIG:remove:qcom = "gstreamer"
