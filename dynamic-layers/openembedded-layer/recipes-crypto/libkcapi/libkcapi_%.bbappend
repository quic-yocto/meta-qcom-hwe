PACKAGECONFIG:append:qcom = "testapp"
