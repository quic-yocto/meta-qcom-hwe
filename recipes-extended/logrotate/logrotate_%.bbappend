
LOGROTATE_SYSTEMD_TIMER_BASIS:qcom = "*-*-* *:00/5:00"
LOGROTATE_SYSTEMD_TIMER_ACCURACY:qcom = "1s"
