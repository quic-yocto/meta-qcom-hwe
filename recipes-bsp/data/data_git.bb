DESCRIPTION = "Qualcomm Technologies Data Modules"

LICENSE          = "Qualcomm-Technologies-Inc.-Proprietary"
LIC_FILES_CHKSUM = "file://qti/src/qti.h;beginline=16;endline=19;md5=b8aa1cd0e8c728c6a47607252d441f74"

SRC_URI   = "git://qpm-git.qualcomm.com/home2/git/revision-history/platform/vendor/qcom-proprietary/ship/data.git;protocol=https;rev=0de74873597fef58fe24937ede39c25f6e5e732f;branch=1020-data.qclinux.1.0.r1-rel;destsuffix=data"

S = "${WORKDIR}/data"
