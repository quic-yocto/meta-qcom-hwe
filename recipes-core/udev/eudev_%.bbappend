inherit relative_symlinks

BBCLASSEXTEND = "native nativesdk"
