PV:qcom-base-bsp = "2.11"

LIC_FILES_CHKSUM:qcom-base-bsp = "file://COPYING;md5=5ebcb90236d1ad640558c3d3cd3035df \
                                  file://README;beginline=1;endline=56;md5=6e4b25e7d74bfc44a32ba37bdf5210a6 \
                                  file://wpa_supplicant/wpa_supplicant.c;beginline=1;endline=12;md5=f5ccd57ea91e04800edb88267bf8eae4"

SRC_URI[sha256sum] = "912ea06f74e30a8e36fbb68064d6cdff218d8d591db0fc5d75dee6c81ac7fc0a"
